# remove dependency on perl
PACKAGES_remove = "${PN}-misc"
RDEPENDS_${PN}_remove = "${PN}-misc"

