include linux-glowforge.inc
SRC_URI += "file://debug.cfg"

COMPATIBLE_MACHINE = "(glowforge-dev)"
