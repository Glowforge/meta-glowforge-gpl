# reorder so lib/uuid/COPYING doesn't clobber COPYING during do_populate_lic
LIC_FILES_CHKSUM = "file://lib/uuid/COPYING;md5=58dcd8452651fc8b07d1f65ce07ca8af \
                    file://COPYING;md5=b48f21d765b875bd10400975d12c1ca2 \
                    file://lib/ext2fs/ext2fs.h;beginline=1;endline=9;md5=596a8dedcb4e731c6b21c7a46fba6bef \
                    file://lib/e2p/e2p.h;beginline=1;endline=7;md5=8a74ade8f9d65095d70ef2d4bf48e36a \
                    file://lib/uuid/uuid.h.in;beginline=1;endline=32;md5=dbb8079e114a5f841934b99e59c8820a \
                    file://lib/et/et_name.c;beginline=1;endline=11;md5=ead236447dac7b980dbc5b4804d8c836 \
                    file://lib/ss/mit-sipb-copyright.h;md5=7248d27f8ee1bd462000ace7523c8c07"
