ATTRIBUTION = "file://glib/glib.h;endline=23 \
               file://gmodule/gmodule.h;endline=23 \
               file://glib/pcre/pcre.h;beginline=8;endline=35"

