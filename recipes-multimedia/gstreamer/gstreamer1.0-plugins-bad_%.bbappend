ATTRIBUTION = "file://gst/tta/crc32.h;endline=29 \
               file://gst/tta/filters.h;endline=29"
PACKAGECONFIG = ""
