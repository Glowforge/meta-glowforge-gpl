PACKAGECONFIG = "jpeg"

